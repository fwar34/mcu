# IAR project test_1602.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\安装程序\MCU\stm8_projects\test_1602-v3; D:\安装程序\MCU\stm8_projects\test_1602-v3\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: test_1602.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STDLib
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c
  group User
    ./: delay.c delay.h dht11.h ds1302.c ds1302.h main.c uart.h
