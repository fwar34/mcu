# Keil uVision project clock-keil-timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: clock-keil-timer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: common.sdcc.c delay.sdcc.c dht11.sdcc.c dht11-timer-sdcc.c ds1302.sdcc.c infrared.sdcc.c infrared2.sdcc.c key.sdcc.c lcd1602.sdcc.c main.sdcc.c timer0.sdcc.c timer1.sdcc.c timer3.sdcc.c uart_sdcc.c
