# Keil uVision project 4bit-1602-ds1302-dht11.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 4bit-1602-ds1302-dht11 +hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./: dht11.h ds1302.h main.c lcd1602.h delay.h ds1302.c lcd1602.c delay.c dht11.c timer.c key.c infrared.c common.c uart_sdcc.c
