<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\aos_stm8_iar.ewp</path>
    </project>
    <batchBuild />
</workspace>
